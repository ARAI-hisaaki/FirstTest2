# Keil uVision project Navigation_System_Arai2015.uvprojx, settings and files
target Navigation_System_Arai2015 (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.pdsc
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: Navigation_System_Arai2015
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DTARGET_NUCLEO_F401RE -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h --split_sections -DMBED_BUILD_TIMESTAMP=1492851670.32 -DTARGET_STM32F401RE -DTARGET_STM32F4 -D__ASSERT_MSG --no_rtti -DDEVICE_PORTINOUT=1 -DTARGET_FF_MORPHO -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DTARGET_RELEASE -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DARM_MATH_CM4 -DUSB_STM_HAL -DDEVICE_I2C=1 -DDEVICE_PORTIN=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -DUSBHOST_OTHER --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_STM32F401xE -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM
  c include: .; MS5607; SDFileSystem; SDFileSystem/FATFileSystem; SDFileSystem/FATFileSystem/ChaN; MPU9250_SPI; INS_GPS; mbed/.; mbed/TARGET_NUCLEO_F401RE; mbed/TARGET_NUCLEO_F401RE/TARGET_STM; mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4; mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE; mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DUSB_STM_HAL,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-DUSBHOST_OTHER,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_STD/stm32f401xe.sct
  group INS_GPS
    INS_GPS/: CalculeMatrix.cpp CalculeMatrix.h Initialization.cpp Initialization.h KalmaFilter.cpp KalmanFilter.h NormalDistribution.cpp NormalDistribution.h RawDataConvert.cpp RawDataConvert.h Strapdown_INS.cpp Strapdown_INS.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    mbed/TARGET_NUCLEO_F401RE/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h hal_tick.h stm32_hal_legacy.h stm32f401xe.h stm32f4xx.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h system_stm32f4xx.h
    mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o hal_tick.o mbed.ar mbed_overrides.o retarget.o startup_stm32f401xe.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_msp_template.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_usb.o sys.o system_stm32f4xx.o
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/: device.h objects.h PeripheralNames.h PinNames.h PortNames.h
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/: gpio_object.h PeripheralPins.h
  group MPU9250_SPI
    MPU9250_SPI/: MPU9250.cpp MPU9250.h
  group MS5607
    MS5607/: MS5607Base.h MS5607I2C.h MS5607SPI.h
  group Navigation_System_Arai2015
    ./: main.cpp mbed_config.h
  group SDFileSystem
    SDFileSystem/FATFileSystem/ChaN/: ccsbcs.cpp diskio.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
    SDFileSystem/FATFileSystem/: FATDirHandle.cpp FATDirHandle.h FATFileHandle.cpp FATFileHandle.h FATFileSystem.cpp FATFileSystem.h MemFileSystem.h
    SDFileSystem/: SDFileSystem.cpp SDFileSystem.h
